# IAR project C300E-INPUT-IAP.ewp, settings and files
configuration Debug_Input (ARM, debug)
  General.OGChipSelectEditMenu: STM32F042x6 ST STM32F042x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F042; USE_DEFAULT_TIMEOUT_CALLBACK; DMP_TYPE_INPUT
  ICCARM.CCIncludePath2: ..\; ..\Libraries\CMSIS\Include; ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; USER
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: C300E-INPUT-IAP.srec
  ILINK.IlinkOutputFile: C300E-INPUT-IAP.out
  ILINK.IlinkIcfFile: E:\work\softwareProject\siwaji\C300E-BOOT\Projects\USER\EWARM\stm32f042x6_iap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release_Input (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F042; USE_DEFAULT_TIMEOUT_CALLBACK; DMP_TYPE_INPUT
  ICCARM.CCOptLevel: 3
configuration Debug_Qifa (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F042; USE_DEFAULT_TIMEOUT_CALLBACK; DMP_TYPE_OUTPUT
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f042x6.icf
configuration Release_Qifa (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F042; USE_DEFAULT_TIMEOUT_CALLBACK; DMP_TYPE_OUTPUT
  ICCARM.CCOptLevel: 3
configuration Debug_Motor (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F042; USE_DEFAULT_TIMEOUT_CALLBACK; DMP_TYPE_MOTOR
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f042x6.icf
configuration Releas_Motor (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F042; USE_DEFAULT_TIMEOUT_CALLBACK; DMP_TYPE_MOTOR
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f042.s
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group ICF
    USER/EWARM/: stm32f042x6_iap.icf
  group STM32F0xx_StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ../Libraries/STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group USER
    USER/: algorithm.c algorithm.h anniuled.c can.c can_dmp.c can_dmp.h can_wp.h cancmd.c cancmd.h crc.c crc.h flash id.c main.c stm32f0xx_it.c timer.c timer.h
